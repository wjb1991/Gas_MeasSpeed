# IAR project Example.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103VE ST STM32F103VE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F103xE; USE_HAL_DRIVER; OS_SUPPORT; xVECT_TAB_SRAM
  ICCARM.CCIncludePath2: ; ..\..\Sources_App\; ..\..\Sources_Bsp\; ..\..\Sources_Mod\; ..\..\Sources_Task\; ..\..\Sources_Public\; ..\..\USB_Host_Library\Core\Inc; ..\..\USB_Host_Library\Class\HID\Inc; ..\..\USB_Host_Library\Class\USB4000\Inc; ..\..\Drivers\CMSIS\Include; ..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include; ..\..\Drivers\STM32F1xx_HAL_Driver\Inc; ..\..\uCOSIII\uC-CONFIG; ..\..\uCOSIII\uC-CPU; ..\..\uCOSIII\uC-CPU\ARM-Cortex-M4\IAR; ..\..\uCOSIII\uC-LIB; ..\..\uCOSIII\uCOS-III\Source; ..\..\uCOSIII\uCOS-III\Ports\ARM-Cortex-M\ARMv7-M\IAR
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Example.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  group CMSIS
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/iar/: startup_stm32f103xe.s
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Sources_App
    ../../Sources_App/: app_main.c app_stdbus.c
  group Sources_Bsp
    ../../Sources_Bsp/: bsp.c bsp_adc.c bsp_clock.c bsp_converter.c bsp_dac.c bsp_gpio.c bsp_os.c bsp_timer.c bsp_usart.c cpu_bsp.c stm32f1xx_hal_msp.c stm32f1xx_it.c
  group Sources_Drive
    ../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_ll_adc.c stm32f1xx_ll_usart.c
  group Sources_Mod
    ../../Sources_Mod/: mod_crc16.c mod_measspeed.c mod_stdbus.c
  group Sources_Task
    ../../Sources_Mod/: mod_softmeas.c
    ../../Sources_Task/: task_cml.c task_measspeed.c task_start.c task_stdbus.c
  group uCOSIII/uC-CONFIG
    ../../uCOSIII/uC-CONFIG/: cpu_cfg.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group uCOSIII/uC-CPU
    ../../uCOSIII/uC-CPU/ARM-Cortex-M4/IAR/: cpu.h cpu_a.asm cpu_c.c
    ../../uCOSIII/uC-CPU/: cpu_cache.h cpu_core.c cpu_core.h cpu_def.h
  group uCOSIII/uC-LIB
    ../../uCOSIII/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../../uCOSIII/uC-LIB/Ports/ARM-Cortex-M4/IAR/: lib_mem_a.asm
  group uCOSIII/uC-OSIII
    ../../uCOSIII/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_mem.c os_mon.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_trace.h os_type.h os_var.c
  group uCOSIII/uC-OSIII/Ports
    ../../uCOSIII/uCOS-III/Ports/ARM-Cortex-M/ARMv7-M/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c
